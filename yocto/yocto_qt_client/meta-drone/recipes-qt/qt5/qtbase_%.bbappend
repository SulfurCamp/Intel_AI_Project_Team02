# QSQLITE 드라이버 빌드 활성화
PACKAGECONFIG:append:pn-qtbase = " sql-sqlite"
